## drivers/net/wireless/rtl8192cu-new/Kconfig
```kconfig
config RTL8192CU_NEW
	tristate "Realtek 8192C USB WiFi"
	depends on USB
	---help---
	  Help message of RTL8192CU
```
